v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 500 -1280 500 -1040 {}
L 4 500 -1040 860 -1040 {}
L 4 860 -1280 860 -1040 {}
L 4 500 -1280 860 -1280 {}
T {FILLERS WITH MOSCAP} 510 -1270 0 0 0.3 0.3 {}
N 80 -880 100 -880 {
lab=VCOIN}
N 340 -900 340 -880 {
lab=#net1}
N 340 -880 540 -880 {
lab=#net1}
N 540 -900 540 -880 {
lab=#net1}
N 540 -880 740 -880 {
lab=#net1}
N 740 -900 740 -880 {
lab=#net1}
N 520 -920 540 -920 {
lab=#net2}
N 720 -920 740 -920 {
lab=#net3}
N 920 -980 920 -920 {
lab=#net4}
N 670 -980 920 -980 {
lab=#net4}
N 340 -980 590 -980 {
lab=#net5}
N 340 -980 340 -920 {
lab=#net5}
N 60 -880 80 -880 {
lab=VCOIN}
N 400 -820 570 -820 {
lab=F6}
N 280 -820 400 -820 {
lab=F6}
N 180 -880 340 -880 {
lab=#net1}
N 180 -880 180 -820 {
lab=#net1}
N 260 -820 280 -820 {
lab=F6}
N 1180 -1400 1220 -1400 {
lab=#net6}
N 1180 -900 1220 -900 {
lab=#net7}
N 1040 -980 1060 -980 {
lab=#net7}
N 1040 -1020 1060 -1020 {
lab=#net8}
N 1040 -1080 1060 -1080 {
lab=#net9}
N 1040 -1120 1060 -1120 {
lab=#net10}
N 1040 -1180 1060 -1180 {
lab=#net10}
N 1040 -1220 1060 -1220 {
lab=#net11}
N 1040 -1280 1060 -1280 {
lab=#net12}
N 1040 -1320 1060 -1320 {
lab=#net6}
N 1040 -1380 1060 -1380 {
lab=#net13}
N 1040 -1420 1060 -1420 {
lab=#net14}
N 1200 -920 1200 -900 {
lab=#net7}
N 1040 -980 1040 -960 {
lab=#net7}
N 1040 -960 1200 -920 {
lab=#net7}
N 1040 -1040 1040 -1020 {
lab=#net8}
N 1200 -1100 1200 -1080 {
lab=#net8}
N 1040 -1040 1200 -1080 {
lab=#net8}
N 1040 -1080 1040 -1060 {
lab=#net9}
N 1040 -1060 1200 -1020 {
lab=#net9}
N 1200 -1020 1200 -1000 {
lab=#net9}
N 1200 -1220 1200 -1200 {
lab=#net12}
N 1200 -1300 1200 -1280 {
lab=#net11}
N 1040 -1280 1040 -1260 {
lab=#net12}
N 1040 -1240 1040 -1220 {
lab=#net11}
N 1040 -1240 1200 -1280 {
lab=#net11}
N 1040 -1260 1200 -1220 {
lab=#net12}
N 1040 -1180 1040 -1120 {
lab=#net10}
N 1200 -1400 1200 -1380 {
lab=#net6}
N 1040 -1340 1200 -1380 {
lab=#net6}
N 1040 -1340 1040 -1320 {
lab=#net6}
N 920 -1380 960 -1380 {
lab=CLK}
N 1040 -920 1060 -920 {
lab=#net15}
N 1300 -1400 1320 -1400 {
lab=#net16}
N 1300 -900 1320 -900 {
lab=#net17}
N 1400 -900 1440 -900 {
lab=#net18}
N 1400 -1400 1430 -1400 {
lab=#net19}
N 1430 -1400 1440 -1400 {
lab=#net19}
N 1380 -1360 1380 -1300 {
lab=#net11}
N 1380 -1360 1440 -1360 {
lab=#net11}
N 1380 -1000 1380 -940 {
lab=#net9}
N 1380 -940 1440 -940 {
lab=#net9}
N 1420 -1320 1440 -1320 {
lab=#net10}
N 1420 -1320 1420 -980 {
lab=#net10}
N 1420 -980 1440 -980 {
lab=#net10}
N 1400 -1140 1420 -1140 {
lab=#net10}
N 1180 -1200 1200 -1200 {
lab=#net12}
N 1180 -1100 1200 -1100 {
lab=#net8}
N 1180 -1300 1380 -1300 {
lab=#net11}
N 1180 -1000 1380 -1000 {
lab=#net9}
N 1280 -1080 1280 -920 {
lab=#net7}
N 1200 -920 1280 -920 {
lab=#net7}
N 1240 -1160 1280 -1160 {
lab=#net6}
N 1240 -1120 1280 -1120 {
lab=#net9}
N 1240 -1120 1240 -1000 {
lab=#net9}
N 1560 -1360 1600 -1360 {
lab=#net14}
N 1580 -1460 1580 -1360 {
lab=#net14}
N 1040 -1460 1580 -1460 {
lab=#net14}
N 1040 -1460 1040 -1420 {
lab=#net14}
N 1040 -880 1060 -880 {
lab=#net20}
N 1040 -880 1040 -840 {
lab=#net20}
N 1040 -840 1580 -840 {
lab=#net20}
N 1580 -940 1580 -840 {
lab=#net20}
N 1560 -940 1600 -940 {
lab=#net20}
N 920 -920 960 -920 {
lab=#net4}
N 1680 -1360 1720 -1360 {
lab=UP}
N 1680 -940 1720 -940 {
lab=DOWN}
N 1220 -1060 1420 -1060 {
lab=#net10}
N 1220 -1150 1220 -1060 {
lab=#net10}
N 1050 -1150 1220 -1150 {
lab=#net10}
N 1040 -1150 1050 -1150 {
lab=#net10}
N 1280 -1300 1280 -1200 {
lab=#net11}
N 1240 -1380 1240 -1160 {
lab=#net6}
N 1200 -1380 1240 -1380 {
lab=#net6}
C {clkbuf_3.sym} 140 -880 0 0 {name=x10 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkbuf_8.sym} 220 -820 0 0 {name=x11 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 430 -910 0 0 {name=x1 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 630 -910 0 0 {name=x2 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 830 -910 0 0 {name=x3 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 630 -980 0 1 {name=x4 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {devices/ipin.sym} 60 -880 0 0 {name=p1 lab=VCOIN}
C {devices/opin.sym} 570 -820 0 0 {name=p2 lab=F6}
C {devices/ipin.sym} 920 -1380 0 0 {name=p4 lab=CLK}
C {devices/opin.sym} 1720 -1360 0 0 {name=p5 lab=UP}
C {devices/opin.sym} 1720 -940 0 0 {name=p9 lab=DOWN}
C {nand2_1.sym} 1120 -1400 0 0 {name=x5 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1000 -1380 0 0 {name=x6 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1120 -1300 2 1 {name=x27 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1120 -1200 2 1 {name=x28 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1120 -1100 0 0 {name=x29 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1120 -1000 0 0 {name=x30 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1120 -900 2 1 {name=x31 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1000 -920 0 0 {name=x32 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand3_1.sym} 1500 -1360 2 1 {name=x33 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand3_1.sym} 1500 -940 0 0 {name=x34 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand4_1.sym} 1340 -1140 0 0 {name=x35 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1260 -1400 0 0 {name=x36 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1360 -1400 0 0 {name=x37 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1260 -900 0 0 {name=x38 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1360 -900 0 0 {name=x39 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1640 -1360 0 0 {name=x40 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1640 -940 0 0 {name=x41 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_16.sym} 560 -1100 0 0 {name=x7 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_8.sym} 560 -1160 0 0 {name=x8 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 560 -1220 0 0 {name=x9 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 620 -1220 0 0 {name=x12 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 680 -1220 0 0 {name=x13 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 740 -1220 0 0 {name=x14 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 800 -1220 0 0 {name=x15 VDD=VDD VNW=VDD VPW=0 VSS=0 prefix=gf180mcu_fd_sc_mcu7t5v0__ }
