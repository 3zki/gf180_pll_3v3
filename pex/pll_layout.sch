v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 1130 -800 1130 -560 {}
L 4 1130 -560 1490 -560 {}
L 4 1490 -800 1490 -560 {}
L 4 1130 -800 1490 -800 {}
T {PLL LVS schematic} 1170 0 2 0 0.4 0.4 {}
T {From https://github.com/noritsuna/Chipathon2023_PLL_VCO} 420 -160 0 0 0.4 0.4 {}
T {FILLERS WITH MOSCAP} 1140 -790 0 0 0.3 0.3 {}
N -410 -520 -410 -420 {
lab=#net1}
N -410 -610 -410 -580 {
lab=VDD}
N -140 -610 -140 -580 {
lab=VDD}
N -140 -590 -110 -590 {
lab=VDD}
N -110 -590 -110 -550 {
lab=VDD}
N -140 -550 -110 -550 {
lab=VDD}
N -440 -550 -410 -550 {
lab=VDD}
N -440 -590 -440 -550 {
lab=VDD}
N -440 -590 -410 -590 {
lab=VDD}
N -140 -520 -140 -290 {
lab=#net2}
N -140 -230 -140 -180 {
lab=VSS}
N -410 -360 -410 -290 {
lab=#net3}
N -410 -230 -410 -180 {
lab=VSS}
N -410 -390 -380 -390 {
lab=VSS}
N -380 -390 -380 -200 {
lab=VSS}
N -410 -440 -330 -440 {
lab=#net1}
N -330 -440 -330 -330 {
lab=#net1}
N -170 -260 -140 -260 {
lab=VSS}
N -170 -210 -140 -210 {
lab=VSS}
N -100 -260 40 -260 {
lab=#net2}
N -510 -390 -490 -390 {
lab=VCTRL}
N -490 -390 -450 -390 {
lab=VCTRL}
N -430 -260 -430 -220 {
lab=VSS}
N -430 -220 -410 -220 {
lab=VSS}
N -350 -300 -330 -300 {
lab=VSS}
N -350 -220 -330 -220 {
lab=VSS}
N -330 -270 -330 -250 {
lab=#net4}
N -350 -300 -350 -220 {
lab=VSS}
N -370 -550 -180 -550 {
lab=#net1}
N -410 -460 50 -460 {
lab=#net1}
N -320 -550 -320 -460 {
lab=#net1}
N -170 -260 -170 -210 {
lab=VSS}
N -350 -220 -350 -190 {
lab=VSS}
N -380 -200 -380 -190 {
lab=VSS}
N -410 -620 660 -620 {
lab=VDD}
N -410 -620 -410 -610 {
lab=VDD}
N -140 -620 -140 -610 {
lab=VDD}
N -410 -180 40 -180 {
lab=VSS}
N -330 -190 -330 -180 {
lab=VSS}
N -350 -190 -350 -180 {
lab=VSS}
N -380 -190 -380 -180 {
lab=VSS}
N -500 -180 -410 -180 {
lab=VSS}
N -510 -620 -410 -620 {
lab=VDD}
N -860 -470 -840 -470 {
lab=VDD}
N -840 -500 -840 -470 {
lab=VDD}
N -860 -500 -840 -500 {
lab=VDD}
N -860 -440 -860 -340 {
lab=#net5}
N -900 -470 -900 -310 {
lab=FREERUN}
N -860 -280 -860 -250 {
lab=VSS}
N -860 -390 -720 -390 {
lab=#net5}
N -860 -310 -840 -310 {
lab=VSS}
N -840 -310 -840 -280 {
lab=VSS}
N -860 -280 -840 -280 {
lab=VSS}
N -680 -410 -680 -370 {
lab=#net5}
N -720 -390 -680 -390 {
lab=#net5}
N -680 -470 -680 -450 {
lab=VSS}
N -680 -330 -680 -310 {
lab=VDD}
N -680 -270 -680 -250 {
lab=VSS}
N -710 -330 -710 -250 {
lab=EX}
N -650 -330 -650 -250 {
lab=VCTRL}
N -900 -210 -680 -210 {
lab=FREERUN}
N -900 -310 -900 -210 {
lab=FREERUN}
N -680 -610 -680 -570 {
lab=FREERUN}
N -680 -530 -680 -510 {
lab=VDD}
N -710 -530 -710 -450 {
lab=LF}
N -650 -530 -650 -450 {
lab=VCTRL}
N -900 -610 -680 -610 {
lab=FREERUN}
N -900 -610 -900 -470 {
lab=FREERUN}
N -650 -490 -620 -490 {
lab=VCTRL}
N -650 -290 -620 -290 {
lab=VCTRL}
N -620 -490 -620 -290 {
lab=VCTRL}
N -760 -290 -710 -290 {
lab=EX}
N -940 -390 -900 -390 {
lab=FREERUN}
N -620 -390 -510 -390 {
lab=VCTRL}
N -860 -620 -510 -620 {
lab=VDD}
N -860 -250 -860 -180 {
lab=VSS}
N -860 -180 -500 -180 {
lab=VSS}
N 970 -420 970 -400 {
lab=#net6}
N 970 -400 1170 -400 {
lab=#net6}
N 1170 -420 1170 -400 {
lab=#net6}
N 1170 -400 1370 -400 {
lab=#net6}
N 1370 -420 1370 -400 {
lab=#net6}
N 1150 -440 1170 -440 {
lab=#net7}
N 1350 -440 1370 -440 {
lab=#net8}
N 1550 -500 1550 -440 {
lab=#net9}
N 1300 -500 1550 -500 {
lab=#net9}
N 970 -500 1220 -500 {
lab=#net10}
N 970 -500 970 -440 {
lab=#net10}
N 1030 -340 1200 -340 {
lab=F6}
N 910 -340 1030 -340 {
lab=F6}
N 810 -400 970 -400 {
lab=#net6}
N 810 -400 810 -340 {
lab=#net6}
N 890 -340 910 -340 {
lab=F6}
N 1810 -920 1850 -920 {
lab=#net11}
N 1810 -420 1850 -420 {
lab=#net12}
N 1670 -500 1690 -500 {
lab=#net12}
N 1670 -540 1690 -540 {
lab=#net13}
N 1670 -600 1690 -600 {
lab=#net14}
N 1670 -640 1690 -640 {
lab=#net15}
N 1670 -700 1690 -700 {
lab=#net15}
N 1670 -740 1690 -740 {
lab=#net16}
N 1670 -800 1690 -800 {
lab=#net17}
N 1670 -840 1690 -840 {
lab=#net11}
N 1670 -900 1690 -900 {
lab=#net18}
N 1670 -940 1690 -940 {
lab=#net19}
N 1830 -440 1830 -420 {
lab=#net12}
N 1670 -500 1670 -480 {
lab=#net12}
N 1670 -480 1830 -440 {
lab=#net12}
N 1670 -560 1670 -540 {
lab=#net13}
N 1830 -620 1830 -600 {
lab=#net13}
N 1670 -560 1830 -600 {
lab=#net13}
N 1670 -600 1670 -580 {
lab=#net14}
N 1670 -580 1830 -540 {
lab=#net14}
N 1830 -540 1830 -520 {
lab=#net14}
N 1830 -740 1830 -720 {
lab=#net17}
N 1830 -820 1830 -800 {
lab=#net16}
N 1670 -800 1670 -780 {
lab=#net17}
N 1670 -760 1670 -740 {
lab=#net16}
N 1670 -760 1830 -800 {
lab=#net16}
N 1670 -780 1830 -740 {
lab=#net17}
N 1670 -700 1670 -640 {
lab=#net15}
N 1830 -920 1830 -900 {
lab=#net11}
N 1670 -860 1830 -900 {
lab=#net11}
N 1670 -860 1670 -840 {
lab=#net11}
N 1550 -900 1590 -900 {
lab=CLK}
N 1670 -440 1690 -440 {
lab=#net20}
N 1930 -920 1950 -920 {
lab=#net21}
N 1930 -420 1950 -420 {
lab=#net22}
N 2030 -420 2070 -420 {
lab=#net23}
N 2030 -920 2060 -920 {
lab=#net24}
N 2060 -920 2070 -920 {
lab=#net24}
N 2010 -880 2010 -820 {
lab=#net16}
N 2010 -880 2070 -880 {
lab=#net16}
N 2010 -520 2010 -460 {
lab=#net14}
N 2010 -460 2070 -460 {
lab=#net14}
N 2050 -840 2070 -840 {
lab=#net15}
N 2050 -840 2050 -500 {
lab=#net15}
N 2050 -500 2070 -500 {
lab=#net15}
N 2030 -660 2050 -660 {
lab=#net15}
N 1810 -720 1830 -720 {
lab=#net17}
N 1810 -620 1830 -620 {
lab=#net13}
N 1810 -820 2010 -820 {
lab=#net16}
N 1810 -520 2010 -520 {
lab=#net14}
N 1910 -600 1910 -440 {
lab=#net12}
N 1830 -440 1910 -440 {
lab=#net12}
N 1870 -680 1910 -680 {
lab=#net11}
N 1870 -640 1910 -640 {
lab=#net14}
N 1870 -640 1870 -520 {
lab=#net14}
N 2190 -880 2230 -880 {
lab=#net19}
N 2210 -980 2210 -880 {
lab=#net19}
N 1670 -980 2210 -980 {
lab=#net19}
N 1670 -980 1670 -940 {
lab=#net19}
N 1670 -400 1690 -400 {
lab=#net25}
N 1670 -400 1670 -360 {
lab=#net25}
N 1670 -360 2210 -360 {
lab=#net25}
N 2210 -460 2210 -360 {
lab=#net25}
N 2190 -460 2230 -460 {
lab=#net25}
N 1550 -440 1590 -440 {
lab=#net9}
N 2310 -880 2350 -880 {
lab=UP}
N 2310 -460 2350 -460 {
lab=DOWN}
N 1850 -580 2050 -580 {
lab=#net15}
N 1850 -670 1850 -580 {
lab=#net15}
N 1680 -670 1850 -670 {
lab=#net15}
N 1670 -670 1680 -670 {
lab=#net15}
N 1910 -820 1910 -720 {
lab=#net16}
N 1870 -900 1870 -680 {
lab=#net11}
N 1830 -900 1870 -900 {
lab=#net11}
N 190 -620 190 -580 {
lab=VDD}
N 190 -580 220 -580 {
lab=VDD}
N 220 -580 220 -470 {
lab=VDD}
N 190 -470 220 -470 {
lab=VDD}
N 190 -550 220 -550 {
lab=VDD}
N 190 -520 190 -500 {
lab=#net26}
N 190 -440 190 -370 {
lab=#net27}
N 150 -470 150 -340 {
lab=#net28}
N 190 -310 190 -290 {
lab=#net29}
N 190 -340 220 -340 {
lab=VSS}
N 220 -340 220 -230 {
lab=VSS}
N 190 -230 220 -230 {
lab=VSS}
N 190 -260 220 -260 {
lab=VSS}
N 50 -510 150 -510 {
lab=#net1}
N 150 -550 150 -510 {
lab=#net1}
N 50 -510 50 -460 {
lab=#net1}
N 40 -300 150 -300 {
lab=#net2}
N 150 -300 150 -260 {
lab=#net2}
N 40 -180 190 -180 {
lab=VSS}
N 190 -230 190 -180 {
lab=VSS}
N 290 -620 290 -580 {
lab=VDD}
N 290 -580 320 -580 {
lab=VDD}
N 320 -580 320 -470 {
lab=VDD}
N 290 -470 320 -470 {
lab=VDD}
N 290 -550 320 -550 {
lab=VDD}
N 290 -520 290 -500 {
lab=#net30}
N 290 -440 290 -370 {
lab=#net31}
N 250 -470 250 -340 {
lab=#net27}
N 290 -310 290 -290 {
lab=#net32}
N 290 -340 320 -340 {
lab=VSS}
N 320 -340 320 -230 {
lab=VSS}
N 290 -230 320 -230 {
lab=VSS}
N 290 -260 320 -260 {
lab=VSS}
N 150 -510 250 -510 {
lab=#net1}
N 250 -550 250 -510 {
lab=#net1}
N 250 -300 250 -260 {
lab=#net2}
N 290 -230 290 -180 {
lab=VSS}
N 390 -620 390 -580 {
lab=VDD}
N 390 -580 420 -580 {
lab=VDD}
N 420 -580 420 -470 {
lab=VDD}
N 390 -470 420 -470 {
lab=VDD}
N 390 -550 420 -550 {
lab=VDD}
N 390 -520 390 -500 {
lab=#net33}
N 390 -440 390 -370 {
lab=#net34}
N 350 -470 350 -340 {
lab=#net31}
N 390 -310 390 -290 {
lab=#net35}
N 390 -340 420 -340 {
lab=VSS}
N 420 -340 420 -230 {
lab=VSS}
N 390 -230 420 -230 {
lab=VSS}
N 390 -260 420 -260 {
lab=VSS}
N 250 -510 350 -510 {
lab=#net1}
N 350 -550 350 -510 {
lab=#net1}
N 350 -300 350 -260 {
lab=#net2}
N 390 -230 390 -180 {
lab=VSS}
N 250 -300 350 -300 {
lab=#net2}
N 150 -300 250 -300 {
lab=#net2}
N 490 -620 490 -580 {
lab=VDD}
N 490 -580 520 -580 {
lab=VDD}
N 520 -580 520 -470 {
lab=VDD}
N 490 -470 520 -470 {
lab=VDD}
N 490 -550 520 -550 {
lab=VDD}
N 490 -520 490 -500 {
lab=#net36}
N 490 -440 490 -370 {
lab=#net37}
N 450 -470 450 -340 {
lab=#net34}
N 490 -310 490 -290 {
lab=#net38}
N 490 -340 520 -340 {
lab=VSS}
N 520 -340 520 -230 {
lab=VSS}
N 490 -230 520 -230 {
lab=VSS}
N 490 -260 520 -260 {
lab=VSS}
N 350 -510 450 -510 {
lab=#net1}
N 450 -550 450 -510 {
lab=#net1}
N 450 -300 450 -260 {
lab=#net2}
N 490 -230 490 -180 {
lab=VSS}
N 350 -300 450 -300 {
lab=#net2}
N 590 -620 590 -580 {
lab=VDD}
N 590 -580 620 -580 {
lab=VDD}
N 620 -580 620 -470 {
lab=VDD}
N 590 -470 620 -470 {
lab=VDD}
N 590 -550 620 -550 {
lab=VDD}
N 590 -520 590 -500 {
lab=#net39}
N 590 -440 590 -370 {
lab=#net28}
N 550 -470 550 -340 {
lab=#net37}
N 590 -310 590 -290 {
lab=#net40}
N 590 -340 620 -340 {
lab=VSS}
N 620 -340 620 -230 {
lab=VSS}
N 590 -230 620 -230 {
lab=VSS}
N 590 -260 620 -260 {
lab=VSS}
N 450 -510 550 -510 {
lab=#net1}
N 550 -550 550 -510 {
lab=#net1}
N 550 -300 550 -260 {
lab=#net2}
N 590 -230 590 -180 {
lab=VSS}
N 450 -300 550 -300 {
lab=#net2}
N 690 -620 690 -580 {
lab=VDD}
N 690 -580 720 -580 {
lab=VDD}
N 720 -580 720 -470 {
lab=VDD}
N 690 -470 720 -470 {
lab=VDD}
N 690 -550 720 -550 {
lab=VDD}
N 690 -520 690 -500 {
lab=#net41}
N 690 -440 690 -370 {
lab=#net42}
N 650 -470 650 -340 {
lab=#net28}
N 690 -310 690 -290 {
lab=#net43}
N 690 -340 720 -340 {
lab=VSS}
N 720 -340 720 -230 {
lab=VSS}
N 690 -230 720 -230 {
lab=VSS}
N 690 -260 720 -260 {
lab=VSS}
N 550 -510 650 -510 {
lab=#net1}
N 650 -550 650 -510 {
lab=#net1}
N 650 -300 650 -260 {
lab=#net2}
N 690 -230 690 -180 {
lab=VSS}
N 550 -300 650 -300 {
lab=#net2}
N 660 -620 690 -620 {
lab=VDD}
N 190 -180 690 -180 {
lab=VSS}
N 40 -300 40 -260 {
lab=#net2}
N -140 -300 40 -300 {
lab=#net2}
N 190 -380 250 -380 {
lab=#net27}
N 290 -380 350 -380 {
lab=#net31}
N 390 -380 450 -380 {
lab=#net34}
N 490 -380 550 -380 {
lab=#net37}
N 150 -420 590 -420 {
lab=#net28}
N 590 -380 650 -380 {
lab=#net28}
N 650 -400 730 -400 {
lab=#net28}
N 820 -220 820 -180 {
lab=VSS}
N 690 -180 820 -180 {
lab=VSS}
N 2740 -680 2740 -640 {
lab=OUT}
N 2670 -610 2700 -610 {
lab=DOWN}
N 2530 -680 2530 -640 {
lab=#net44}
N 2660 -710 2700 -710 {
lab=#net44}
N 2490 -710 2490 -610 {
lab=UP}
N 2470 -710 2490 -710 {
lab=UP}
N 2530 -710 2550 -710 {
lab=VDD}
N 2530 -610 2550 -610 {
lab=VSS}
N 2740 -710 2760 -710 {
lab=VDD}
N 2740 -610 2760 -610 {
lab=VSS}
N 2930 -680 2930 -640 {
lab=#net45}
N 2970 -710 3000 -710 {
lab=UP}
N 3140 -680 3140 -640 {
lab=#net46}
N 2970 -610 3010 -610 {
lab=#net46}
N 3010 -660 3010 -610 {
lab=#net46}
N 3010 -660 3140 -660 {
lab=#net46}
N 3180 -710 3180 -610 {
lab=DOWN}
N 3180 -610 3200 -610 {
lab=DOWN}
N 3120 -710 3140 -710 {
lab=VDD}
N 3120 -610 3140 -610 {
lab=VSS}
N 2910 -710 2930 -710 {
lab=VDD}
N 2910 -610 2930 -610 {
lab=VSS}
N 2740 -740 2930 -740 {
lab=#net47}
N 2740 -580 2930 -580 {
lab=#net48}
N 2710 -660 2740 -660 {
lab=OUT}
N 2640 -710 2660 -710 {
lab=#net44}
N 2530 -670 2640 -670 {
lab=#net44}
N 2640 -710 2640 -670 {
lab=#net44}
N 2910 -530 2930 -530 {
lab=VSS}
N 2910 -450 2930 -450 {
lab=VSS}
N 2740 -920 2740 -900 {
lab=VDD}
N 2740 -870 2760 -870 {
lab=VDD}
N 2740 -790 2760 -790 {
lab=VDD}
N 2740 -840 2740 -820 {
lab=#net49}
N 2700 -830 2700 -790 {
lab=#net50}
N 2700 -910 2700 -870 {
lab=#net51}
N 2880 -910 3240 -910 {
lab=#net51}
N 2880 -830 3240 -830 {
lab=#net50}
N 2930 -500 2930 -480 {
lab=#net52}
N 2930 -420 2930 -400 {
lab=VSS}
N 2970 -530 2970 -490 {
lab=#net53}
N 2970 -450 2970 -410 {
lab=#net54}
N 2740 -760 2740 -740 {
lab=#net47}
N 3140 -920 3140 -740 {
lab=VDD}
N 3120 -920 3120 -710 {
lab=VDD}
N 2910 -920 2910 -710 {
lab=VDD}
N 2760 -920 2760 -710 {
lab=VDD}
N 2530 -920 2530 -740 {
lab=VDD}
N 2550 -920 2550 -710 {
lab=VDD}
N 3140 -580 3140 -400 {
lab=VSS}
N 3120 -610 3120 -400 {
lab=VSS}
N 2760 -610 2760 -400 {
lab=VSS}
N 2930 -580 2930 -560 {
lab=#net48}
N 2550 -610 2550 -400 {
lab=VSS}
N 2530 -580 2530 -400 {
lab=VSS}
N 2530 -400 3140 -400 {
lab=VSS}
N 2930 -920 2930 -900 {
lab=VDD}
N 2910 -870 2930 -870 {
lab=VDD}
N 2910 -790 2930 -790 {
lab=VDD}
N 2930 -840 2930 -820 {
lab=#net55}
N 2970 -830 2970 -790 {
lab=#net50}
N 2970 -910 2970 -870 {
lab=#net51}
N 2930 -760 2930 -740 {
lab=#net47}
N 2910 -610 2910 -400 {
lab=VSS}
N 2740 -530 2760 -530 {
lab=VSS}
N 2740 -450 2760 -450 {
lab=VSS}
N 2740 -500 2740 -480 {
lab=#net56}
N 2740 -420 2740 -400 {
lab=VSS}
N 2700 -530 2700 -490 {
lab=#net53}
N 2700 -450 2700 -410 {
lab=#net54}
N 2740 -580 2740 -560 {
lab=#net48}
N 2700 -410 2880 -410 {
lab=#net54}
N 2700 -490 2880 -490 {
lab=#net53}
N 2700 -910 2880 -910 {
lab=#net51}
N 2700 -830 2880 -830 {
lab=#net50}
N 2530 -920 3120 -920 {
lab=VDD}
N 3120 -920 3140 -920 {
lab=VDD}
N 2880 -490 3240 -490 {
lab=#net53}
N 2880 -410 3240 -410 {
lab=#net54}
N 3740 -890 3760 -890 {
lab=VDD}
N 3760 -920 3760 -890 {
lab=VDD}
N 3660 -890 3700 -890 {
lab=CSVB}
N 3740 -920 3760 -920 {
lab=VDD}
N 3600 -890 3620 -890 {
lab=VDD}
N 3600 -920 3600 -890 {
lab=VDD}
N 3600 -920 3620 -920 {
lab=VDD}
N 3620 -920 3740 -920 {
lab=VDD}
N 3620 -530 3640 -530 {
lab=VSS}
N 3640 -530 3640 -400 {
lab=VSS}
N 3620 -450 3640 -450 {
lab=VSS}
N 3620 -500 3620 -480 {
lab=#net57}
N 3620 -420 3620 -400 {
lab=VSS}
N 3660 -400 3760 -400 {
lab=VSS}
N 3680 -490 3700 -490 {
lab=#net53}
N 3680 -730 3740 -730 {
lab=#net53}
N 3580 -530 3580 -490 {
lab=#net53}
N 3580 -450 3580 -410 {
lab=#net54}
N 3560 -410 3580 -410 {
lab=#net54}
N 3540 -490 3680 -490 {
lab=#net53}
N 3680 -600 3680 -490 {
lab=#net53}
N 3740 -770 3740 -690 {
lab=#net53}
N 3620 -400 3660 -400 {
lab=VSS}
N 3620 -770 3620 -690 {
lab=#net54}
N 3480 -530 3500 -530 {
lab=VSS}
N 3480 -450 3500 -450 {
lab=VSS}
N 3480 -500 3480 -480 {
lab=#net58}
N 3480 -420 3480 -400 {
lab=VSS}
N 3440 -530 3440 -490 {
lab=#net53}
N 3440 -450 3440 -410 {
lab=#net54}
N 3440 -490 3540 -490 {
lab=#net53}
N 3440 -410 3560 -410 {
lab=#net54}
N 3480 -400 3620 -400 {
lab=VSS}
N 3500 -530 3500 -400 {
lab=VSS}
N 3340 -920 3340 -900 {
lab=VDD}
N 3340 -870 3360 -870 {
lab=VDD}
N 3340 -790 3360 -790 {
lab=VDD}
N 3360 -920 3360 -790 {
lab=VDD}
N 3340 -840 3340 -820 {
lab=#net59}
N 3300 -830 3300 -790 {
lab=#net50}
N 3300 -910 3300 -870 {
lab=#net51}
N 3280 -720 3340 -720 {
lab=#net51}
N 3480 -920 3480 -820 {
lab=VDD}
N 3480 -790 3500 -790 {
lab=VDD}
N 3500 -920 3500 -790 {
lab=VDD}
N 3300 -830 3440 -830 {
lab=#net50}
N 3440 -830 3440 -790 {
lab=#net50}
N 3420 -720 3480 -720 {
lab=#net50}
N 3400 -920 3500 -920 {
lab=VDD}
N 3480 -760 3480 -720 {
lab=#net50}
N 3340 -760 3340 -720 {
lab=#net51}
N 3420 -830 3420 -720 {
lab=#net50}
N 3280 -910 3300 -910 {
lab=#net51}
N 3280 -910 3280 -720 {
lab=#net51}
N 3340 -920 3400 -920 {
lab=VDD}
N 3480 -720 3480 -690 {
lab=#net50}
N 3340 -530 3360 -530 {
lab=VSS}
N 3340 -450 3360 -450 {
lab=VSS}
N 3340 -500 3340 -480 {
lab=#net60}
N 3340 -420 3340 -400 {
lab=VSS}
N 3300 -530 3300 -490 {
lab=#net53}
N 3300 -450 3300 -410 {
lab=#net54}
N 3300 -490 3400 -490 {
lab=#net53}
N 3360 -530 3360 -400 {
lab=VSS}
N 3340 -400 3480 -400 {
lab=VSS}
N 3400 -490 3440 -490 {
lab=#net53}
N 3300 -410 3440 -410 {
lab=#net54}
N 3340 -720 3340 -690 {
lab=#net51}
N 3240 -830 3300 -830 {
lab=#net50}
N 3240 -910 3280 -910 {
lab=#net51}
N 3620 -860 3620 -770 {
lab=#net54}
N 3740 -860 3740 -770 {
lab=#net53}
N 3680 -830 3880 -830 {
lab=CSVB}
N 3500 -920 3600 -920 {
lab=VDD}
N 3550 -590 3550 -410 {
lab=#net54}
N 3550 -730 3620 -730 {
lab=#net54}
N 3550 -730 3550 -720 {
lab=#net54}
N 3680 -890 3680 -830 {
lab=CSVB}
N 3740 -470 3760 -470 {
lab=VSS}
N 3740 -440 3740 -400 {
lab=VSS}
N 3700 -490 3700 -470 {
lab=#net53}
N 3240 -410 3300 -410 {
lab=#net54}
N 3240 -490 3300 -490 {
lab=#net53}
N 3140 -400 3330 -400 {
lab=VSS}
N 3330 -400 3340 -400 {
lab=VSS}
N 3140 -920 3340 -920 {
lab=VDD}
N 3340 -690 3340 -560 {
lab=#net51}
N 3480 -690 3480 -560 {
lab=#net50}
N 3550 -720 3550 -590 {
lab=#net54}
N 3620 -690 3620 -560 {
lab=#net54}
N 3740 -690 3740 -560 {
lab=#net53}
N 3680 -730 3680 -600 {
lab=#net53}
N 3760 -470 3760 -400 {
lab=VSS}
N 3740 -560 3740 -500 {
lab=#net53}
N 2350 -880 2350 -710 {
lab=UP}
N 2350 -710 2470 -710 {
lab=UP}
N 2670 -610 2670 -460 {
lab=DOWN}
N 2350 -460 2670 -460 {
lab=DOWN}
N -290 -300 -210 -300 {
lab=#net53}
N -210 -300 -210 -150 {
lab=#net53}
N -290 -220 -240 -220 {
lab=#net54}
N -240 -220 -240 -120 {
lab=#net54}
N -210 -150 -210 -140 {
lab=#net53}
N -210 -140 2930 -140 {
lab=#net53}
N -240 -120 3000 -120 {
lab=#net54}
N 3000 -490 3000 -140 {
lab=#net53}
N 2930 -140 3000 -140 {
lab=#net53}
N 3000 -120 3020 -120 {
lab=#net54}
N 3020 -410 3020 -120 {
lab=#net54}
N 690 -1160 690 -620 {
lab=VDD}
N 690 -1160 2520 -1160 {
lab=VDD}
N 2520 -1160 2530 -1160 {
lab=VDD}
N 2530 -1160 2530 -920 {
lab=VDD}
N 820 -180 2520 -180 {
lab=VSS}
N 2520 -180 2530 -180 {
lab=VSS}
N 2530 -400 2530 -180 {
lab=VSS}
N 3000 -750 3000 -710 {
lab=UP}
N 2350 -750 3000 -750 {
lab=UP}
N 3200 -610 3200 -570 {
lab=DOWN}
N 2670 -570 3200 -570 {
lab=DOWN}
N 3910 -190 4030 -190 {
lab=VSS}
N 4030 -660 4040 -660 {
lab=VSS}
N 4040 -660 4040 -620 {
lab=VSS}
N 3900 -710 3910 -710 {
lab=VSS}
N 3900 -710 3900 -670 {
lab=VSS}
N 4030 -920 4030 -900 {
lab=VDD}
N 3910 -920 4030 -920 {
lab=VDD}
N 3910 -920 3910 -900 {
lab=VDD}
N 4030 -870 4040 -870 {
lab=VDD}
N 4040 -910 4040 -870 {
lab=VDD}
N 4030 -910 4040 -910 {
lab=VDD}
N 3900 -870 3910 -870 {
lab=VDD}
N 3900 -910 3900 -870 {
lab=VDD}
N 3900 -910 3910 -910 {
lab=VDD}
N 3950 -870 3990 -870 {
lab=CSVB}
N 3910 -830 3960 -830 {
lab=CSVB}
N 3960 -870 3960 -830 {
lab=CSVB}
N 4030 -620 4040 -620 {
lab=VSS}
N 3910 -680 3910 -610 {
lab=#net61}
N 3950 -710 4030 -710 {
lab=#net62}
N 3910 -660 3990 -660 {
lab=#net61}
N 3930 -580 3940 -580 {
lab=VSS}
N 3940 -580 3940 -530 {
lab=VSS}
N 4030 -840 4030 -690 {
lab=#net62}
N 3910 -840 3910 -740 {
lab=CSVB}
N 3930 -490 3940 -490 {
lab=VSS}
N 3940 -490 3940 -440 {
lab=VSS}
N 4030 -630 4030 -280 {
lab=VSS}
N 3910 -550 3910 -520 {
lab=#net63}
N 3910 -460 3910 -430 {
lab=#net64}
N 3880 -830 3910 -830 {
lab=CSVB}
N 4030 -280 4030 -190 {
lab=VSS}
N 3940 -530 3940 -490 {
lab=VSS}
N 3910 -370 3910 -320 {
lab=#net65}
N 3910 -260 3910 -190 {
lab=VSS}
N 3930 -400 3940 -400 {
lab=VSS}
N 3940 -400 3940 -190 {
lab=VSS}
N 3930 -290 3940 -290 {
lab=VSS}
N 3940 -440 3940 -400 {
lab=VSS}
N 3900 -190 3910 -190 {
lab=VSS}
N 3760 -920 3910 -920 {
lab=VDD}
N 3760 -190 3900 -190 {
lab=VSS}
N 3760 -400 3760 -190 {
lab=VSS}
N 3900 -670 3900 -190 {
lab=VSS}
N -1180 -530 -710 -530 {
lab=LF}
N -1530 -470 -1530 -450 {
lab=VSS}
N -1530 -530 -1430 -530 {
lab=OUT}
N -1430 -470 -1430 -450 {
lab=#net66}
N -1430 -390 -1430 -370 {
lab=VSS}
N -1270 -510 -1270 -180 {
lab=VSS}
N -1180 -470 -1180 -180 {
lab=VSS}
N -1450 -420 -1450 -180 {
lab=VSS}
N -1430 -370 -1430 -180 {
lab=VSS}
N -1530 -450 -1530 -180 {
lab=VSS}
N -1400 -180 -860 -180 {
lab=VSS}
N -1400 -1080 2620 -1080 {
lab=OUT}
N 2620 -1080 2620 -660 {
lab=OUT}
N 2620 -660 2710 -660 {
lab=OUT}
N -860 -620 -860 -500 {
lab=VDD}
N -1150 -470 -1150 -180 {
lab=VSS}
N -1120 -470 -1120 -180 {
lab=VSS}
N -1090 -470 -1090 -180 {
lab=VSS}
N -1060 -470 -1060 -180 {
lab=VSS}
N -1030 -470 -1030 -180 {
lab=VSS}
N -1000 -470 -1000 -180 {
lab=VSS}
N -970 -470 -970 -180 {
lab=VSS}
N -1210 -470 -1210 -180 {
lab=VSS}
N -1240 -470 -1240 -180 {
lab=VSS}
N -1240 -530 -1180 -530 {
lab=LF}
N -1360 -530 -1300 -530 {
lab=OUT}
N -1430 -530 -1360 -530 {
lab=OUT}
N -1530 -1080 -1530 -530 {
lab=OUT}
N -1530 -1080 -1400 -1080 {
lab=OUT}
N -1530 -180 -1400 -180 {
lab=VSS}
N -1430 -470 -1330 -470 {
lab=#net66}
C {symbols/pfet_03v3.sym} -160 -550 0 0 {name=M25
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -390 -550 0 1 {name=M26
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -430 -390 0 0 {name=M27
L=0.33u
W=0.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -120 -260 0 1 {name=M28
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -310 -300 0 1 {name=M7
L=0.33u
W=8u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -310 -220 0 1 {name=M8
L=0.33u
W=8u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {devices/iopin.sym} -860 -620 0 1 {name=p3 lab=VDD}
C {devices/iopin.sym} -860 -180 3 1 {name=p4 lab=VSS}
C {ppolyf_u_lvs.sym} -410 -260 0 0 {name=R1
W=0.8e-6
L=260e-6
model=ppolyf_u
m=1}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_03v3.sym} -880 -470 0 0 {name=M1
L=0.28u
W=3u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_03v3.sym} -880 -310 0 0 {name=M2
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_03v3.sym} -680 -350 3 1 {name=M3
L=0.33u
W=60u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_03v3.sym} -680 -430 3 0 {name=M4
L=0.33u
W=20u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} -680 -470 0 0 {name=p8 sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -680 -310 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_03v3.sym} -680 -230 3 0 {name=M5
L=0.33u
W=20u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} -680 -270 0 0 {name=p10 sig_type=std_logic lab=VSS}
C {pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_03v3.sym} -680 -550 3 1 {name=M6
L=0.33u
W=60u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} -680 -510 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {devices/ipin.sym} -940 -390 0 0 {name=p12 lab=FREERUN}
C {devices/ipin.sym} -760 -290 0 0 {name=p14 lab=EX}
C {devices/title.sym} 160 -30 0 0 {name=l1 author="Mizuki Mori"}
C {clkbuf_3.sym} 770 -400 0 0 {name=x10 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkbuf_8.sym} 850 -340 0 0 {name=x11 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 1060 -430 0 0 {name=x7 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 1260 -430 0 0 {name=x8 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {dffq_1.sym} 1460 -430 0 0 {name=x9 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1260 -500 0 1 {name=x12 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {devices/opin.sym} 1200 -340 0 0 {name=p7 lab=F6}
C {devices/ipin.sym} 1550 -900 0 0 {name=p15 lab=CLK}
C {nand2_1.sym} 1750 -920 0 0 {name=x13 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1630 -900 0 0 {name=x14 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1750 -820 2 1 {name=x27 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1750 -720 2 1 {name=x28 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1750 -620 0 0 {name=x29 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1750 -520 0 0 {name=x30 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand2_1.sym} 1750 -420 2 1 {name=x31 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1630 -440 0 0 {name=x32 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand3_1.sym} 2130 -880 2 1 {name=x33 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand3_1.sym} 2130 -460 0 0 {name=x34 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {nand4_1.sym} 1970 -660 0 0 {name=x35 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1890 -920 0 0 {name=x36 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1990 -920 0 0 {name=x37 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1890 -420 0 0 {name=x38 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 1990 -420 0 0 {name=x39 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 2270 -880 0 0 {name=x40 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {clkinv_1.sym} 2270 -460 0 0 {name=x41 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_16.sym} 1190 -620 0 0 {name=x15 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_8.sym} 1190 -680 0 0 {name=x16 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1190 -740 0 0 {name=x17 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1250 -740 0 0 {name=x18 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1310 -740 0 0 {name=x19 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1370 -740 0 0 {name=x20 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1430 -740 0 0 {name=x21 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {symbols/pfet_03v3.sym} 170 -550 0 0 {name=M9
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 170 -470 0 0 {name=M10
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 170 -340 0 0 {name=M11
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 170 -260 0 0 {name=M12
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 270 -550 0 0 {name=M13
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 270 -470 0 0 {name=M14
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 270 -340 0 0 {name=M15
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 270 -260 0 0 {name=M16
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 370 -550 0 0 {name=M17
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 370 -470 0 0 {name=M18
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 370 -340 0 0 {name=M19
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 370 -260 0 0 {name=M20
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 470 -550 0 0 {name=M21
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 470 -470 0 0 {name=M22
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 470 -340 0 0 {name=M23
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 470 -260 0 0 {name=M24
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 570 -550 0 0 {name=M29
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 570 -470 0 0 {name=M30
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 570 -340 0 0 {name=M31
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 570 -260 0 0 {name=M32
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 670 -550 0 0 {name=M33
L=0.33u
W=0.9u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 670 -470 0 0 {name=M34
L=0.33u
W=1.8u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 670 -340 0 0 {name=M35
L=0.33u
W=0.84u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 670 -260 0 0 {name=M36
L=0.33u
W=0.42u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3_dn
spiceprefix=X
}
C {fillcap_16.sym} 1250 -620 0 0 {name=x1 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_16.sym} 1310 -620 0 0 {name=x2 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {fillcap_4.sym} 1250 -680 0 0 {name=x3 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {antenna.sym} 870 -220 0 0 {name=x4 VDD=VDD VNW=VDD VPW=VSS VSS=VSS prefix=gf180mcu_fd_sc_mcu7t5v0__ }
C {symbols/pfet_03v3.sym} 2950 -710 0 1 {name=M37
L=0.33u
W=8u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2950 -610 0 1 {name=M38
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3160 -710 0 1 {name=M39
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3160 -610 0 1 {name=M40
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2950 -530 0 1 {name=M41
L=0.33u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2950 -450 0 1 {name=M42
L=0.33u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2950 -870 0 1 {name=M43
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2950 -790 0 1 {name=M44
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2720 -870 0 0 {name=M45
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2720 -790 0 0 {name=M46
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2720 -710 0 0 {name=M47
L=0.33u
W=8u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2720 -610 0 0 {name=M48
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2720 -530 0 0 {name=M49
L=0.33u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2720 -450 0 0 {name=M50
L=0.33u
W=1u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2510 -710 0 0 {name=M51
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2510 -610 0 0 {name=M52
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3720 -890 0 0 {name=M53
L=0.56u
W=4.48u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3640 -890 0 1 {name=M54
L=0.56u
W=4.48u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3600 -530 0 0 {name=M55
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3600 -450 0 0 {name=M56
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3460 -530 0 0 {name=M57
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3460 -450 0 0 {name=M58
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3320 -870 0 0 {name=M59
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3320 -790 0 0 {name=M60
L=0.33u
W=4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3460 -790 0 0 {name=M61
L=0.33u
W=0.8u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3320 -530 0 0 {name=M62
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3320 -450 0 0 {name=M63
L=0.33u
W=2u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3720 -470 0 0 {name=M64
L=0.33u
W=0.4u
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3930 -870 0 1 {name=M65
L=0.56u
W=5.6u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4010 -870 0 0 {name=M66
L=0.56u
W=5.6u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3930 -710 0 1 {name=M67
L=0.56u
W=5.6u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4010 -660 0 0 {name=M68
L=0.56u
W=5.6u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {ppolyf_u_lvs.sym} 3910 -580 0 1 {name=R2
W=0.8e-6
L=22e-6
model=ppolyf_u
m=1}
C {ppolyf_u_lvs.sym} 3910 -490 0 1 {name=R3
W=0.8e-6
L=22e-6
model=ppolyf_u
m=1}
C {ppolyf_u_lvs.sym} 3910 -400 0 1 {name=R4
W=0.8e-6
L=22e-6
model=ppolyf_u
m=1}
C {ppolyf_u_lvs.sym} 3910 -290 0 1 {name=R5
W=0.8e-6
L=22e-6
model=ppolyf_u
m=1}
C {devices/iopin.sym} 2350 -710 0 1 {name=p1 lab=UP}
C {devices/iopin.sym} 2360 -460 1 1 {name=p2 lab=DOWN}
C {devices/iopin.sym} 3810 -830 3 1 {name=p5 lab=CSVB}
C {devices/iopin.sym} -520 -390 3 1 {name=p6 lab=VCTRL}
C {cap_mim_2p0fF_lvs.sym} -1180 -500 0 0 {name=C3
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {ppolyf_u_lvs.sym} -1270 -530 3 0 {name=x5
W=1e-6
L=200e-6
model=ppolyf_u_1k
m=1}
C {cap_mim_2p0fF_lvs.sym} -1530 -500 0 0 {name=C1
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {ppolyf_u_lvs.sym} -1430 -420 0 0 {name=x6
W=1e-6
L=460e-6
model=ppolyf_u_1k
m=1}
C {devices/iopin.sym} -1040 -530 1 1 {name=p13 lab=LF}
C {devices/iopin.sym} 2620 -660 3 1 {name=p16 lab=OUT}
C {cap_mim_2p0fF_lvs.sym} -1150 -500 0 0 {name=C4
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1120 -500 0 0 {name=C5
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1090 -500 0 0 {name=C6
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1060 -500 0 0 {name=C7
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1030 -500 0 0 {name=C8
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1000 -500 0 0 {name=C9
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -970 -500 0 0 {name=C10
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1210 -500 0 0 {name=C11
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1240 -500 0 0 {name=C12
W=10e-6
L=5e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1430 -500 0 0 {name=C22
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1420 -500 0 0 {name=C2
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1410 -500 0 0 {name=C13
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1400 -500 0 0 {name=C14
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1390 -500 0 0 {name=C15
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1380 -500 0 0 {name=C16
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1370 -500 0 0 {name=C17
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1360 -500 0 0 {name=C18
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1350 -500 0 0 {name=C19
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1340 -500 0 0 {name=C20
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
C {cap_mim_2p0fF_lvs.sym} -1330 -500 0 0 {name=C21
W=11e-6
L=11e-6
model=cap_mim_2f0_m4m5_noshield}
